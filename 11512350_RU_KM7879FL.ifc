Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-12-17T09:30:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 17 09:30:02 2020 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{CA60969C-D778-416D-8C94-E53A5B8F93D6}\ifc * Database version: 5507 * Database creation date: Thu Dec 17 09:30:01 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 17 09:30:01 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 17 09:30:01 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26787970_RU_11512350_KM7879FL, 11512350_RU_KM7879FL:26787970_RU_11512350_KM7879FL:207674
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_Glass Black
Pset_BuildingElementProxyCommon - Reference: 26787970_RU_11512350_KM7879FL
Pset_ManufacturerTypeInformation - Manufacturer: Miele
